## boards/boardsource/blok/board.yml
```yaml
board:
  name: boardsource_blok
  full_name: boardsource_blok
  vendor: boardsource
  socs:
    - name: rp2040
```
